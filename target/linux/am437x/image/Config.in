## target/linux/am437x/image/Config.in
```kconfig
config AM437X_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_am437x
	default 40
```
